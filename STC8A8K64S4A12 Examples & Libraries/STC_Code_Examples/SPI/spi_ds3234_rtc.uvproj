# Keil uVision project spi_ds3234_rtc.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: spi_ds3234_rtc +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\My_Libraries\Device Header Files;.\My_Libraries\LCD;.\My_Libraries\DS3234
  group Source Group 1
    ./: STARTUP.A51 main.c
