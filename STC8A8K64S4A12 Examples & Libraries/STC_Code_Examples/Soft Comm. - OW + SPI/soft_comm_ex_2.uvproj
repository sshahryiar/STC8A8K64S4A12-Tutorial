# Keil uVision project soft_comm_ex_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: soft_comm_ex_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\My_Libraries\Device Header Files;.\My_Libraries\DHT11;.\My_Libraries\SSD1306
  group Source Group 1
    ./: STARTUP.A51 main.c
