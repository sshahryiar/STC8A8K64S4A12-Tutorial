# Keil uVision project GPIO.uvproj, settings and files
target Target (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: GPIO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\My_Libraries\Device Header Files
  group Source Group
    ./: STARTUP.A51 main.c
