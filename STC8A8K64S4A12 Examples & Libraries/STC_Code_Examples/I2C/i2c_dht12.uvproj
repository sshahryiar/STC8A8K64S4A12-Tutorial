# Keil uVision project i2c_dht12.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: i2c_dht12 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\My_Libraries\Device Header Files;.\My_Libraries\LCD;.\My_Libraries\DHT12
  group Source Group 1
    ./: STARTUP.A51 main.c
